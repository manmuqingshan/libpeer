## zephyr/Kconfig
```kconfig
menu "libpeer"

config LIBPEER
	bool "Enable libpeer module"
	default n
	depends on CJSON && LIBSRTP
	help
	  Enable libpeer integration for Zephyr builds.

endmenu
```
